## boards/shields/minila/Kconfig.defconfig
```kconfig
if SHIELD_MINILA
    config ZMK_KEYBOARD_NAME
        default "Minila"

    config SPI
        default y
endif
```
